# Keil uVision project AM11_Bootloader.uvprojx, settings and files
target Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SY7T_M11_bootloader +hex
  AfterMake: .\hex2c\hex2c.bat
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: SER2=1
  c include: Header Files
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x800
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\System Files\SY7T_M11_bootloader.sct
  link misc: --entry=boot
  group Startup Files
    ./System Files/: startup_SY7T_M11_boot_keil.s
  group Source Files
    ./BL_Source_Files/: boot.c
