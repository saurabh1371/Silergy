# Keil uVision project SY7T108_1p2w_shunt_ct_dlms_1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SY7T108_1p2w_shunt_ct_dlms_1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SY7T108_1P2W_SHUNT_CT=1  DLMS_STACK=1 ASDAQ=1
  c include: ..\Silergy_BSP\cm0\include;..\Silergy_BSP\drivers\include;..\Silergy_BSP\library\include;..\Silergy_BSP\SY7T108\drivers\include;..\Meter_App\include;..\Meter_App\dlms_common;..\Meter_App\dlms;..\Meter_App\DLMS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x800
  memory RVCT5: ROM 0x800 size 0x1f800
  memory RVCT9: RAM 0x20000800 size 0x2800
  scatter file: .\System_Files\SY7T_M11_APP_BL.sct
  link misc: --pad=0xFF
  group App
    ../Meter_App/main/: main.c asdaq_app.c asdaq_variables.c
    ../Meter_App/meter/: meter_1p2w.c
    ../Meter_App/LCD/: Lcd_Approved_LCD_For_Rajasthan.c
    ../Meter_App/cli/: cli_stub.c
  group Config
    ../Meter_App/include/: mapdb_am11_0_1.h mapeb_am11_1.h mapeb11_1.h
  group Drivers
    ../Silergy_BSP/drivers/src/bat/: bat.c
    ../Silergy_BSP/drivers/src/ce/: ce.c
    ../Silergy_BSP/drivers/src/delay/: delay.c
    ../Silergy_BSP/drivers/src/dtimer/: dtimer.c dtimer0.c dtimer1.c
    ../Silergy_BSP/drivers/src/eeprom/: eeprom_i2c.c
    ../Silergy_BSP/drivers/src/external_int/: external_int.c
    ../Silergy_BSP/drivers/src/flash/: flash.c
    ../Silergy_BSP/drivers/src/gpio/: gpio.c
    ../Silergy_BSP/drivers/src/i2c/: i2c_master.c
    ../Silergy_BSP/drivers/src/info_block/: info_block.c
    ../Silergy_BSP/drivers/src/nvram/: nvram.c
    ../Silergy_BSP/drivers/src/opt/: opt.c
    ../Silergy_BSP/drivers/src/pwm/: pwm0.c pwm1.c
    ../Silergy_BSP/drivers/src/pwrmode/: pwrmode.c
    ../Silergy_BSP/drivers/src/rtc/: rtc.c
    ../Silergy_BSP/drivers/src/serial/: ser0.c ser1.c ser2.c
    ../Silergy_BSP/drivers/src/sspi/: sspi.c
    ../Silergy_BSP/drivers/src/systick/: systick.c
    ../Silergy_BSP/drivers/src/timer/: timer0.c timer1.c
    ../Silergy_BSP/drivers/src/tmp/: tmp.c
    ../Silergy_BSP/drivers/src/tmux/: tmux.c
    ../Silergy_BSP/drivers/src/wd/: wd.c
    ../Silergy_BSP/library/src/afe/: afe_0_1.c
    ../Silergy_BSP/library/src/cal/: cal_eeprom.c
    ../Silergy_BSP/library/src/cli_buf/: cli_buf.c cli_buf_str_en.c
    ../Silergy_BSP/library/src/crc/: crc.c
    ../Silergy_BSP/library/src/dst/: dst_in.c
    ../Silergy_BSP/library/src/hash/: hash_str.c
    ../Silergy_BSP/library/src/log/: log_by_record.c
    ../Silergy_BSP/library/src/mmath/: mmath.c
    ../Silergy_BSP/library/src/reg/: reg_eeprom.c
    ../Silergy_BSP/library/src/sspi/: sspi0.c
    ../Silergy_BSP/library/src/stm/: stmrtc.c
    ../Silergy_BSP/library/src/tamper/: tamper.c
    ../Silergy_BSP/library/src/time/: time.c
    ../Silergy_BSP/library/src/serc/: serc0.c
    ../Silergy_BSP/SY7T108/drivers/src/ceM11a02f/: autocalceM11a02f.c ceM11a02f.c
  group System
    ../Silergy_BSP/SY7T108/drivers/src/sys/: startup_SY7T108_keil.s system_SY7T108.c
    ./System_Files/: bl_array.c
  group DLMS
    ../Meter_App/DLMS/: aes.c dlms_cosem.c dlms_hdlc.c meter_dlms_objects.c meter_dlms_profiles.c
