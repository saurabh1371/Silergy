# Keil uVision project SY7T108_1p2w_shunt_ct_dlms_1.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SY7T108_1p2w_shunt_ct_dlms_1 +hex
  AfterMake: .\\Objects\\align_hex.bat
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SY7T108_1P2W_SHUNT_CT=1  DLMS_STACK=1 ASDAQ=1
  c include: ../include;../../../drivers/include;../../../../cm0/include;../../../../drivers/include;../../../../library/include;../src/dlms_common;../src/dlms
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x800
  memory RVCT5: ROM 0x800 size 0x1f800
  memory RVCT9: RAM 0x20000800 size 0x2800
  scatter file: .\System_Files\SY7T_M11_APP_BL.sct
  link misc: --pad=0xFF
  group Startup Files
    ../../../drivers/src/sys/: startup_SY7T108_keil.s system_SY7T108.c
  group Commom Driver Files
    ../../../../drivers/src/bat/: bat.c
    ../../../../drivers/src/ce/: ce.c
    ../../../../drivers/src/delay/: delay.c
    ../../../../drivers/src/dtimer/: dtimer.c dtimer0.c dtimer1.c
    ../../../../drivers/src/eeprom/: eeprom_i2c.c
    ../../../../drivers/src/external_int/: external_int.c
    ../../../../drivers/src/flash/: flash.c
    ../../../../drivers/src/gpio/: gpio.c
    ../../../../drivers/src/i2c/: i2c_master.c
    ../../../../drivers/src/info_block/: info_block.c
    ../../../../drivers/src/nvram/: nvram.c
    ../../../../drivers/src/opt/: opt.c
    ../../../../drivers/src/pwm/: pwm0.c pwm1.c
    ../../../../drivers/src/pwrmode/: pwrmode.c
    ../../../../drivers/src/rtc/: rtc.c
    ../../../../drivers/src/serial/: ser0.c ser1.c ser2.c
    ../../../../drivers/src/sspi/: sspi.c
    ../../../../drivers/src/systick/: systick.c
    ../../../../drivers/src/timer/: timer0.c timer1.c
    ../../../../drivers/src/tmp/: tmp.c
    ../../../../drivers/src/tmux/: tmux.c
    ../../../../drivers/src/wd/: wd.c
  group Library Files
    ../../../../library/src/afe/: afe_0_1.c
    ../../../../library/src/cal/: cal_eeprom.c
    ../../../../library/src/cli_buf/: cli_buf.c cli_buf_str_en.c
    ../../../../library/src/crc/: crc.c
    ../../../../library/src/dst/: dst_in.c
    ../../../../library/src/hash/: hash_str.c
    ../../../../library/src/log/: log_by_record.c
    ../../../../library/src/mmath/: mmath.c
    ../../../../library/src/reg/: reg_eeprom.c
    ../../../../library/src/sspi/: sspi0.c
    ../../../../library/src/stm/: stmrtc.c
    ../../../../library/src/tamper/: tamper.c
    ../../../../library/src/time/: time.c
    ../../../../library/src/serc/: serc0.c
  group SoC Driver Files
    ../../../drivers/src/ceM11a02f/: autocalceM11a02f.c ceM11a02f.c
  group Application Files
    ../src/main/: main.c
    ../src/meter/: meter_1p2w.c
    ../src/cli/: cli_stub.c
    ./System_Files/: bl_array.c
    ../src/LCD/: Lcd_Approved_LCD_For_Rajasthan.c
  group Dlms Files
    ../src/dlms/: dlms_hdlc.lib dlmsif.c dlmsif_timer.c dlms_app.lib dlms_objects.c dlms_variables.c dlms_obj.lib dlmsif_dayprofile.c dlmsif_instparams.c dlmsif_loadsurvey.c dlmsif_misc_params.c dlmsif_tampers.c dlmsif_tou.c dlms_utils.c dlms_silergy_stubs.c asdaq_app.c asdaq_variables.c
